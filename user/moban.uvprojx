# Keil uVision project moban.uvprojx, settings and files
target moban (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: moban +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\stm32f103\libraries;.\stm32f103\startup;.\user;.\system;.\app;.\app\MPU6050_DMP;.\app\PWM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: stm32f10x_conf.h main.c
  group system
    ./system/: sys.c delay.c usart1.c usart2.c usart3.c tim_tim.c
  group startup
    ./stm32f103/startup/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group libraries
    ./stm32f103/libraries/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group app
    ./app/: SysTick.c soft_timer.c key.c multi_button.c
  group MPU6050_DMP
    ./app/MPU6050_DMP/: mpu6050_io_iic.c mpu6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050_dmp.c
    ./app/PWM/: run.h run.c pwm.h pwm.c led.h led.c pid.h pid.c
